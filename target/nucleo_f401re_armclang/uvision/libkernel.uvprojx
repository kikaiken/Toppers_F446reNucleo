# Keil uVision project libkernel.uvprojx, settings and files
target libkernel (6090000::V6.9::.\ARMCLANG)
  device: STM32F401RETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IRAM(0x20000000,0x00018000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: libkernel (library)
  BeforeMake: ../../../cfg/cfg/cfg --pass 3 --kernel asp -I. -I../../../ -I../../../include -I../../../arch -I../..  -I../../../target/nucleo_f401re_armclang -I../../../target/nucleo_f401re_gcc/stm32fcube -I../../../arch/arm_m_armclang/stm32f4xx_stm32cube -I../../../arch/arm_m_gcc/stm32f4xx_stm32cube -I../../../arch/arm_m_gcc/stm32f4xx_stm32cube/STM32F4xx_HAL_Driver/Inc -I../../../arch/arm_m_gcc/stm32f4xx_stm32cube/CMSIS/Device/ST/STM32F4xx/Include -I../../../arch/arm_m_gcc/stm32f4xx_stm32cube/CMSIS/Include -I../../../arch/arm_m_armclang/common -I../../../arch/arm_m_gcc/common -I../../../arch/armclang -I../../../target/nucleo_f401re_gcc --rom-image cfg1_out.srec --symbol-table cfg1_out.syms -T ../../../arch/arm_m_gcc/stm32f4xx_stm32cube/chip_offset.tf --api-table ../../../kernel/kernel_api.csv --cfg1-def-table ../../../kernel/kernel_def.csv  --cfg1-def-table ../../../arch/arm_m_gcc/common/core_def.csv sample1.cfg
  c flags: Optim=7
  c define: STM32F401xE,TOPPERS_CORTEX_M4,ALLFUNC,__TARGET_ARCH_THUMB=4,TOPPERS_FPU_ENABLE,TOPPERS_FPU_LAZYSTACKING,TOPPERS_FPU_CONTEXT
  c misc: -mlittle-endian
  c include: .; ../../../; ../../../include; ../../../arch; ../.. ; ../../../target/nucleo_f401re_armclang; ../../../target/nucleo_f401re_gcc/stm32fcube; ../../../arch/arm_m_armclang/stm32f4xx_stm32cube; ../../../arch/arm_m_gcc/stm32f4xx_stm32cube; ../../../arch/arm_m_gcc/stm32f4xx_stm32cube/STM32F4xx_HAL_Driver/Inc; ../../../arch/arm_m_gcc/stm32f4xx_stm32cube/CMSIS/Device/ST/STM32F4xx/Include; ../../../arch/arm_m_gcc/stm32f4xx_stm32cube/CMSIS/Include; ../../../arch/arm_m_armclang/common; ../../../arch/arm_m_gcc/common; ../../../arch/armclang; ../../../target/nucleo_f401re_gcc; ../../../kernel
  asm define: as above
  asm misc: -mlittle-endian
  asm include: as above
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group kernel
    ../../../kernel/: alarm.c cyclic.c dataqueue.c eventflag.c exception.c interrupt.c mailbox.c mempfix.c pridataq.c semaphore.c startup.c sys_manage.c task.c task_except.c task_manage.c task_refer.c task_sync.c time_event.c time_manage.c wait.c
  group target
    ../../nucleo_f401re_gcc/: target_config.c
    ../../nucleo_f401re_gcc/stm32fcube/: stm32f4xx_nucleo.c system_stm32f4xx.c systemclock_config.c
  group arch
    ../../../arch/arm_m_gcc/common/: core_config.c core_timer.c core_support.S
    ../../../arch/arm_m_armclang/common/: core_weak.S
software components: CMSIS:CORE 5.0.1
